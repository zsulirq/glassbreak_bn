# IAR project ear.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: Compile.cpp Ear.cpp main.cpp
  group data
    Data/: Config.cpp Config.h Data.h DataReader.cpp DataReader.h FileIO.cpp FileIO.h MicSource.cpp MicSource.h PushSource.cpp PushSource.h Utils.cpp Utils.h WavSource.cpp WavSource.h
  group features
    Features/: Coeffs.cpp Coeffs.h Feature.cpp Feature.h Filter.cpp Filter.h Frame.cpp Frame.h Transform.cpp Transform.h
  group network
    Network/: Dictionary.cpp Dictionary.h FSTAssembly.cpp FSTAssembly.h HTKAcousticModel.cpp HTKAcousticModel.h
  group search
    Search/: AcousticScorer.cpp AcousticScorer.h Search.cpp Search.h Token.cpp Token.h
